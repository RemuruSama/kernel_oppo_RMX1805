## drivers/input/oppo_fp_drivers/fpc1020/Kconfig
```kconfig
config FINGERPRINT_FPC_1020
       tristate "FPC Fingerprint"
       default y
       help
          FPC Fingerprint.
```
